# Keil uVision project ucos.uvproj, settings and files
target UCOS2 (ARM-ADS)
  device: STM32F401RE STMicroelectronics
  cpu: IROM(0x08000000,0x60000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ucos +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F4XX,USE_STDPERIPH_DRIVER,__FPU_PRESENT
  c include: ..\applications\inc;..\bsp\inc;..\librarys\CMSIS\Include;..\librarys\CMSIS\Device\ST\STM32F4xx\Include;..\librarys\STM32F4xx_StdPeriph_Driver\inc;..\ucos\port;..\ucos\source;..\system
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group startup
    ../librarys/CMSIS/Device/ST/STM32F4xx/Source/arm/: startup_stm32f4xx.s
    ../librarys/CMSIS/Device/ST/STM32F4xx/Source/: system_stm32f4xx.c
  group applications
    ../applications/inc/: os_cfg.h stm32f4xx_conf.h
    ../applications/src/: main.c stm32f4xx_it.c
  group ucos_port
    ../ucos/port/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg_r.c
  group ucos_lib
    ../ucos/source/: ucos_ii.h os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group readme
    ../: readme.txt
  group system
    ../system/: com.c delay.c flash.c IIC.c IMU.c mpu6050.c PIDcontral.c ppm.c Retarget.c Serial.c sys.c temp.c tim.c
  group stm32fxlib
    ../librarys/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
